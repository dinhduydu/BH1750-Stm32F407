<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BH1750_F4_25_10_22.ewp</path>
  </project>
  <batchBuild />
</workspace>
